#include <REGX52.H>
#include "Delay.h"
#include "Mled.h"
sbit RCK=P3^5;//RCLK上沿锁存
sbit SCK=P3^6;//SRCLK上沿移位
sbit SER=P3^4;
unsigned char move[]={
	0x78,0x84,0x82,0x41,0x41,0x82,0x84,0x78,
	0x78,0xFC,0xC6,0x43,0x43,0xC6,0xFC,0x78,
	0x78,0xFC,0xFE,0x67,0x67,0xFE,0xFC,0x78,
	0x78,0xFC,0xFE,0x67,0x67,0xFE,0xFC,0x78,
	0x78,0xFC,0xFE,0x7F,0x7F,0xFE,0xFC,0x78,
	
};
unsigned char i,offset,count;
void main()
{
	LED_Init();

	while (1)
	{
		
		for(i=0;i<8;i++)
		{
			MLED_Show(i,move[i+offset]);
		}
		count++;
		if(count>10)
		{
			count=0;
			offset+=8;
			if(offset==24){offset=0;}
		}
		
	}
}